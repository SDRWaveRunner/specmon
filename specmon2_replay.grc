options:
  parameters:
    author: PE1RIK
    generate_options: qt_gui
    id: specmon2_replay
    output_language: python
  states: {}

blocks:
- name: fftsize
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 145e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '20'
    value: '8.0'
  states: {}
- name: trate
  id: variable_config
  parameters:
    config_file: /tmp/test.conf
    option: trate
    section: main
    type: int
    value: '1'
    writeback: None
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
    vlen: fftsize
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Vector source from filesink of specmon2
    file: /tmp/210928-1510-145000000-2000000-2048.pvector
    repeat: 'False'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/bart/grc/210928-145M-2e6-20g-2048-0.cal
    repeat: 'True'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: trate
    type: float
    vlen: fftsize
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[threshold]*fftsize'
    vlen: fftsize
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      content of configfile /tmp/test.conf:

      [main]
      trate = 100
    note: Reminders
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    comment: |-
      X-start: freq-(samp_rate/2)
      X-step: samp_rate/fftsize
    grid: 'True'
    nconnections: '3'
    showports: 'True'
    vlen: fftsize
    x_start: freq-(samp_rate/2)
    x_step: samp_rate/fftsize
    ymin: '0'
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_1, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_vector_sink_f_0, '2']

metadata:
  file_format: 1
