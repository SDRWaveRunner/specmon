options:
  parameters:
    author: PE1RIK
    generate_options: no_gui
    id: noisemon
    output_language: python
    run_options: run
  states: {}

blocks:
- name: fhandler
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: intcount
  id: variable
  parameters:
    comment: |-
      Integration count.
      Also used for normalisation

      vector_rate is vectors per second

      intcount = samp_rate/(fftsize * vector_rate)

      Bij vector_rate = 5 (200ms):

      intcount = samp_rate/(fftsize * 5)
    value: int(samp_rate/(fftsize * 5))
  states: {}
- name: SCNLimit
  id: parameter
  parameters:
    label: SCN-Limit
    short_id: S
    type: intx
    value: '3'
  states: {}
- name: bbgain
  id: parameter
  parameters:
    label: BB-Gain
    short_id: b
    type: intx
    value: '30'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
    vlen: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Debug option to save vector before
      calibration and specmon2 logics
    file: '"/tmp/" + time.strftime("%y%m%d-%H%M") + "-" + str(int(freq)) + "-" + str(int(samp_rate)) + "-" + str(fftsize) + ".pvector"'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: calibvec
    repeat: 'True'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(runtime*samp_rate)
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: intcount
    type: float
    vlen: fftsize
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '500'
    max_iter: '4000'
    scale: 1.0/500
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normalize integrated vectors
    const: '[1.0/intcount]*fftsize'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: calibvec
  id: parameter
  parameters:
    label: Calibration Vector
    short_id: c
    type: str
    value: '0'
  states: {}
- name: deviceid
  id: parameter
  parameters:
    label: Device ID
    short_id: d
    type: str
    value: '"rtl=00000201"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    short_id: F
    type: intx
    value: '1024'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: eng_float
    value: 145e6
  states: {}
- name: import_0
  id: import
  parameters:
    comment: |-
      Required when not 
      using osmocom source
    imports: import time
  states: {}
- name: noisemon_block
  id: epy_block
  parameters:
    SCNLimit: SCNLimit
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      from scipy.stats import skew


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Noisemon data analysis block. 
          This block is the new version to measure noise levels.
          
          Detect SCN and background noise. No Impulse Noise yet.
          """

      	# Don't use "logfile" as varname as it's reserved in GRC
          #def __init__(self, fftsize=1024, start_state=0, threshold=1.0, verbose=0, reportfile="/tmp/logfile.csv"):  # only default arguments here
          def __init__(self, fftsize=1024, reportfile="/tmp/logfile.csv", threshold=8.0, SCNLimit=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              self.fftsize = fftsize
              self.reportfile = reportfile
              self.threshold = threshold
              self.SCNLimit = SCNLimit
              gr.sync_block.__init__(
                  self,
                  name='Noisemon',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              # Print startline
              self.outfile = open(reportfile, "a")
              print ("Start,%.2f,Hour,%s,Veclen,%i,Threshold,%.2f,SCNLimit,%i" % ( time.time(), str(time.strftime("%H")), self.fftsize, self.threshold, self.SCNLimit), file=self.outfile, flush=True )
              
              # Print header
              print ("N,time,lowlimit,veccount,scncount,nusage,vecmean,vecstd,vecskew,rms,inoise,diff", file=self.outfile, flush=True)
              # Counter for the number of vectors
              self.veccount = 0
              # Buffer for the old STDev
              # Start with high value to prevent first vector as false positive
              # 230514 try an array
              self.oldstdev = []
              
              
          def work(self, input_items, output_items):
              
              for j in range(len(input_items[0])):
                      if len(input_items[0][j]) == self.fftsize:
                              # Correct length
                              
                              # print ("New Vector")
                              
                              speclist = np.array(input_items[0][j])
                              
                              # 220917 trunk the list to the usable value for the Airspy in 2.5MSps
                              # use 0.6, so extract 0.2 on both sides.
                              # See notes on 220917
                              # Use 0.5, so extract 0.25 on both sides.
                              # See notes on 230514
                              #trunklist = speclist[(int(self.fftsize*0.25)):(int(self.fftsize-(self.fftsize*0.25)))]
                              #olist = np.sort(trunklist)
                              
                              olist = np.sort(speclist)
                              
                              # Create a short vector in one place and use everywhere
                              # Use the first 50% for now. ITU-R SM.1753-2 suggest other.
                              # Delete the first 10 values, as these usually hold the DC-spike.
                              shortvec = olist[10:(int(len(olist)/2))]
                              
                              lowlimit = np.median(shortvec)
                              
                              # Stats on the short vector
                              vecmean = np.mean(shortvec)
                              vecstd = np.std(shortvec)
                              
                              # Try to detect Impulse Noise
                              inoise = 0
                              self.oldstdev.append(vecstd)
                              stdevavg = sum(self.oldstdev)/len(self.oldstdev)
                              #if vecstd > (1.25 * self.oldstdev):
                              if vecstd > (1.25 * stdevavg):
                                      inoise = 1
                              
                              # Update oldstdev
                              #self.oldstdev = vecstd
                              if len(self.oldstdev) > 25:
                                      del self.oldstdev[0:1]
                              
                              # Calculate skewness
                              vecskew = skew(shortvec)
                              
                              # Calculate RMS
                              b = np.square(shortvec)
                              vecrms = np.sqrt((np.sum(b)/len(b)))

                              # Now detect SNC (and normal usage)
                              
                              # Create output-vector of lowlimit + threshold
                              #output_items[0][:] = [lowlimit + self.threshold]*self.fftsize
                                                      
                              highcount = 0
                              scncount = 0
                              nusage = 0

                              for i in speclist:
                                  if i < (lowlimit + self.threshold):
                                  #if i == 0:
                                      # Low
                                      #print ("Value is low:  ", i, " Limit: ", (lowlimit + self.threshold) )
                                      
                                      # Now consider highcounter
                                      # If highcounter = 0 nothing before
                                      # If highcounter = 1 consider SCN
                                      # If highcounter > 1 consider normal usage
                                      
                                      if highcount == 0:
                                          # Nothing before
                                          #next
                                          pass
                                      elif highcount <= self.SCNLimit :
                                          # We might have SCN
                                          #print ("SCN Detected")
                                          scncount += 1
                                      elif highcount > self.SCNLimit:
                                          # We might have normal usage
                                          # print ("Normal Usage detected. highcount: ", highcount)
                                          nusage += 1
                                      
                                      # Reset counter
                                      highcount = 0
                                      
                                  else:
                                      # High
                                      #print ("Value is high: ", i, " Limit: ", (lowlimit + self.threshold) )
                                      
                                      # Increase highcounter 
                                      highcount += 1
                                                              
                              #print ("Vectors: ", len(speclist), " SCN: ", scncount, " Normal: ", nusage, " Low: ", lowlimit, " Thresh: ", self.threshold, " Mean: ", vecmean, " STD: ", vecstd)
                              #print ("V: %i L: %i S: %i N: %i L: %.2f T: %.2f M: %.2f std: %.2f" % ( len(speclist), self.SCNLimit, scncount, nusage, lowlimit, self.threshold, vecmean, vecstd ) ) 
                              # Without veclen, scnlimit, threshold (in header)
                              #print ("S: %i N: %i L: %.2f M: %.2f std: %.2f skew: %.2f rms: %.2f" % ( scncount, nusage, lowlimit, vecmean, vecstd, vecskew, vecrms ) ) 

                              
                              
                              # Debug with vector counter
                              self.veccount+=1
                              #print ("N,%.2f,%.2f,%i" % (time.time(), lowlimit, self.veccount), end="\n", file=self.outfile, flush=True )
                              # N,time,lowlimit,scncount, nusage,vecmean,vecstd,veccount
                              print ("N,%.2f,%.2f,%i,%i,%i,%.2f,%.2f,%.2f,%.2f,%i,%.2f" % (time.time(), lowlimit, self.veccount, scncount, nusage, vecmean, vecstd, vecskew, vecrms, inoise, abs(lowlimit-vecmean)), end="\n", file=self.outfile, flush=True )
                      else:
                              print ("Other length input: " + str(len(input_items[0][j])))
              
              return len(input_items[0])
    comment: |-
      Overal moeten de standaardwaarden gelijk zijn,
      in dit geval dus 4096.
      Pas na compilen kan met een parameter de FFTSIZE veranderd
      worden.
    fftsize: fftsize
    reportfile: outfile
    threshold: threshold
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: deviceid
    bb_gain0: bbgain
    dc_offset_mode0: '2'
    freq0: freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: Output File
    short_id: O
    type: str
    value: '"/tmp/logfile.csv"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF-Gain
    short_id: g
    type: intx
    value: '40'
  states: {}
- name: runtime
  id: parameter
  parameters:
    short_id: R
    type: intx
    value: '3590'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 2e6
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold
    short_id: T
    type: eng_float
    value: '8.0'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:50001
    timeout: '100'
    type: float
    vlen: fftsize
  states: {}

connections:
- [blocks_add_xx_0, '0', noisemon_block, '0']
- [blocks_add_xx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_0, '1']
- [blocks_head_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_head_0, '0', blocks_sub_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_add_xx_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_sub_xx_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
