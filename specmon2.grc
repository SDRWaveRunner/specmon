options:
  parameters:
    author: PE1RIK
    generate_options: no_gui
    id: specmon2_auto
    output_language: python
    run_options: run
  states: {}

blocks:
- name: fhandler
  id: variable
  parameters:
    value: '0'
  states: {}
- name: intcount
  id: variable
  parameters:
    comment: |-
      Integration count.
      Also used for normalisation

      vector_rate is vectors per second

      intcount = samp_rate/(fftsize * vector_rate)

      Bij vector_rate = 5 (200ms):

      intcount = samp_rate/(fftsize * 5)
    value: int(samp_rate/(fftsize * 5))
  states: {}
- name: start_state
  id: variable
  parameters:
    value: '0'
  states: {}
- name: bbgain
  id: parameter
  parameters:
    label: BB-Gain
    short_id: b
    type: intx
    value: '30'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
    vlen: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Debug option to save vector before
      calibration and specmon2 logics
    file: '"/tmp/" + time.strftime("%y%m%d-%H%M") + "-" + str(int(freq)) + "-" + str(int(samp_rate)) + "-" + str(fftsize) + ".pvector"'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: calibvec
    repeat: 'True'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(runtime*samp_rate)
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: intcount
    type: float
    vlen: fftsize
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '500'
    max_iter: '4000'
    scale: 1.0/500
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normalize integrated vectors
    const: '[1.0/intcount]*fftsize'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: calibvec
  id: parameter
  parameters:
    label: Calibration Vector
    short_id: c
    type: str
    value: '0'
  states: {}
- name: deviceid
  id: parameter
  parameters:
    label: Device ID
    short_id: d
    type: str
    value: '"rtl=00000201"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    short_id: F
    type: intx
    value: '1024'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: eng_float
    value: 145e6
  states: {}
- name: import_0
  id: import
  parameters:
    comment: |-
      Required when not 
      using osmocom source
    imports: import time
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: deviceid
    bb_gain0: bbgain
    freq0: freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: Output File
    short_id: O
    type: str
    value: '"/tmp/logfile.csv"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF-Gain
    short_id: g
    type: intx
    value: '40'
  states: {}
- name: runtime
  id: parameter
  parameters:
    short_id: R
    type: intx
    value: '3590'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 2e6
  states: {}
- name: specmon_block
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      #from __future__ import print_function
      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Specmon data analysis block. 
          This block is the improved version for specmon.
          220626 Tests with auto threshold value
          
          Threshold value is initial threshold. Will be auto calculated from the noise.
          Initial threshold is value above "zero" so will act as a "squelch" value.
          
          **WARNING**
          Value for lowavg in output is current threshold
          """

      	# Don't use "logfile" as varname as it's reserved in GRC
          def __init__(self, fftsize=1024, start_state=0, threshold=1.0, verbose=0, reportfile="/tmp/logfile.csv"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              self.fftsize = fftsize
              self.start_state = start_state
              self.threshold = threshold
              # Same value fixed in var
              self.initthresh = threshold
              self.verbose = verbose
              self.maxval = 0
              self.sumval = 0
              self.lowcounter = 1
              self.reportfile = reportfile
              gr.sync_block.__init__(
                  self,
                  name='Specmon2_auto',   # will show up in GRC
                  in_sig=[(np.float32,self.fftsize)],
                  out_sig=None
              )
              # Print startline
              self.outfile = open(reportfile, "a")
              print ("S,%.2f,H,%s,T,%.2f" % ( time.time(), str(time.strftime("%H")), threshold ), file=self.outfile, flush=True )
              
          def work(self, input_items, output_items):
              speclist = np.array(input_items[0][0])
              # Peak for max-value
              curval = np.amax(speclist)
              # Median for median noise level
              noiseval = np.median(speclist)
              
              # Auto increment test
              # Order list first
              olist = np.sort(speclist)
              lowlimit = np.median(olist[:(int(self.fftsize/2))])
              
              # Increase this value with initial threshold value. Act as squelch.
              self.threshold = lowlimit + self.initthresh
              
              
              if self.verbose == 1:
                  #print ("%.2f" % curval)
                  print ("Current value: %.2f M %1.2f N %i S %.3f T %.3f" % ( curval, self.maxval, self.lowcounter, self.sumval, self.threshold ) )
                 
              if curval > self.maxval:
                  self.maxval = curval
              
              if curval > self.threshold and self.start_state == 0:
                  # Signal triggers the threshold
                  self.start_state = 1
                  lowavg = self.sumval / self.lowcounter
                  #print ("A,%.2f,%.2f," % ( curval, time.time() ), end="" )
                  #print ("A,%.2f,%.2f," % ( lowavg, time.time() ), end="", file=self.outfile )
                  print ("A,%.2f,%.2f," % ( self.threshold, time.time() ), end="", file=self.outfile )
              elif curval < self.threshold and self.start_state == 1:
                  # Signal drops below threshold
                  #print ("U,%.2f,%.2f" % ( curval, time.time() ), end="\n")
                  print ("U,%.2f,%.2f" % ( self.maxval, time.time() ), end="\n", file=self.outfile, flush=True)
                  self.start_state = 0
                  self.sumval = 0
                  self.lowcounter = 1
                  self.maxval = 0            
              else:
                  # Signal remains under threshold
                  #self.sumval += curval
                  self.sumval += noiseval
                  self.lowcounter += 1
      			
              
              return len(input_items[0])
    fftsize: fftsize
    reportfile: outfile
    start_state: start_state
    threshold: threshold
    verbose: verbose
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold
    short_id: T
    type: eng_float
    value: '.1'
  states: {}
- name: verbose
  id: parameter
  parameters:
    label: Print verbose values
    short_id: v
    type: intx
    value: '0'
  states: {}

connections:
- [blocks_add_xx_0, '0', specmon_block, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_0, '1']
- [blocks_head_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_head_0, '0', blocks_sub_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_add_xx_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_sub_xx_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
