options:
  parameters:
    author: PE1RIK
    generate_options: qt_gui
    id: specmon2_gui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 70e6
    step: 25e3
    stop: 1e9
    value: 145e6
  states: {}
- name: intcount
  id: variable
  parameters:
    comment: |-
      Integration count.
      Also used for normalisation
    value: int(samp_rate/(fftsize * 5))
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: start_state
  id: variable
  parameters:
    value: '0'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '50'
    value: '10'
  states: {}
- name: bbgain
  id: parameter
  parameters:
    label: BB-Gain
    short_id: b
    type: intx
    value: '30'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
    vlen: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: calibvec
    repeat: 'True'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(runtime*samp_rate)
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: intcount
    type: float
    vlen: fftsize
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '500'
    max_iter: '4000'
    scale: 1.0/500
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normalize integrated vectors
    const: '[1.0/intcount]*fftsize'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[threshold]*fftsize'
    vlen: fftsize
  states: {}
- name: calibvec
  id: parameter
  parameters:
    label: Calibration Vector
    short_id: c
    type: str
    value: /home/bart/grc/210926-zero-2048.vec
  states: {}
- name: deviceid
  id: parameter
  parameters:
    label: Device ID
    short_id: d
    type: str
    value: rtl=0
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    short_id: F
    type: intx
    value: '1024'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: deviceid
    bb_gain0: bbgain
    freq0: freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: Output File
    short_id: O
    type: str
    value: '"/tmp/logfile.csv"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: fftsize
    grid: 'True'
    gui_hint: tab0@0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tab0@1
    nconnections: '2'
    showports: 'True'
    vlen: fftsize
    x_start: freq-(samp_rate/2)
    x_step: samp_rate/fftsize
  states: {}
- name: runtime
  id: parameter
  parameters:
    short_id: R
    type: intx
    value: '3590'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 2e6
  states: {}
- name: specmon_block
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      #from __future__ import print_function
      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Specmon data analysis block. 
          This block is the improved version for specmon
          """

      	# Don't use "logfile" as varname as it's reserved in GRC
          def __init__(self, fftsize=1024, start_state=0, threshold=1.0, verbose=0, reportfile="/tmp/logfile.csv"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              self.fftsize = fftsize
              self.start_state = start_state
              self.threshold = threshold
              self.verbose = verbose
              self.maxval = 0
              self.sumval = 0
              self.lowcounter = 1
              self.reportfile = reportfile
              gr.sync_block.__init__(
                  self,
                  name='Specmon2',   # will show up in GRC
                  in_sig=[(np.float32,self.fftsize)],
                  out_sig=None
              )
              # Print startline
              self.outfile = open(reportfile, "a")
              print ("S,%.2f,H,%s,T,%.2f" % ( time.time(), str(time.strftime("%H")), threshold ), file=self.outfile, flush=True )
              
          def work(self, input_items, output_items):
              speclist = np.array(input_items[0][0])
              # Peak for max-value
              curval = np.amax(speclist)
              # Median for median noise level
              noiseval = np.median(speclist)
              if self.verbose == 1:
                  #print ("%.2f" % curval)
                  print ("Current value: %.2f M %1.2f N %i S %.3f" % ( curval, self.maxval, self.lowcounter, self.sumval ) )
                 
              if curval > self.maxval:
                  self.maxval = curval
              
              if curval > self.threshold and self.start_state == 0:
                  # Signal triggers the threshold
                  self.start_state = 1
                  lowavg = self.sumval / self.lowcounter
                  #print ("A,%.2f,%.2f," % ( curval, time.time() ), end="" )
                  print ("A,%.2f,%.2f," % ( lowavg, time.time() ), end="", file=self.outfile )
              elif curval < self.threshold and self.start_state == 1:
                  # Signal drops below threshold
                  #print ("U,%.2f,%.2f" % ( curval, time.time() ), end="\n")
                  print ("U,%.2f,%.2f" % ( self.maxval, time.time() ), end="\n", file=self.outfile, flush=True)
                  self.start_state = 0
                  self.sumval = 0
                  self.lowcounter = 1
                  self.maxval = 0            
              else:
                  # Signal remains under threshold
                  #self.sumval += curval
                  self.sumval += noiseval
                  self.lowcounter += 1
      			
              
              return len(input_items[0])
    fftsize: fftsize
    reportfile: outfile
    start_state: start_state
    threshold: threshold
    verbose: verbose
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    label0: freq sink
    label1: vector sink
    num_tabs: '2'
  states: {}
- name: verbose
  id: parameter
  parameters:
    label: Print verbose values
    short_id: v
    type: intx
    value: '0'
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_add_xx_0, '0', specmon_block, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_0, '1']
- [blocks_head_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_head_0, '0', blocks_sub_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_add_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_sub_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_vector_sink_f_0, '1']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
