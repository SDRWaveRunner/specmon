options:
  parameters:
    author: PE1RIK
    generate_options: qt_gui
    id: specreceive
    output_language: python
    title: Specmon_Receiver
  states: {}

blocks:
- name: threshold
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '20'
    value: '8.0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Constant is a value for correction to real dBm.
      Only to be used after calibration measurement.
    const: ([calconst]*fftsize)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[threshold+calconst]*fftsize'
    vlen: fftsize
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftsize
    type: float
  states: {}
- name: calconst
  id: parameter
  parameters:
    label: calibration-constant
    short_id: c
    type: eng_float
    value: '-132'
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: fft-size
    short_id: F
    type: intx
    value: '4096'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: eng_float
    value: 48e6
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    axislabels: 'False'
    grid: 'True'
    gui_hint: tabje@1
    ncols: fftsize
    nrows: '500'
    samp_rate: '5'
    type: float
    zmax: '-110'
    zmin: '-130'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    comment: |-
      X-start: freq-(samp_rate/2)
      X-step: samp_rate/fftsize
    gui_hint: tabje@0
    label1: Original
    label2: Threshold
    label3: Sorted
    nconnections: '3'
    showports: 'True'
    vlen: fftsize
    x_start: freq-(samp_rate/2)
    x_step: samp_rate/fftsize
    ymax: '-110'
    ymin: '-130'
  states: {}
- name: remote
  id: parameter
  parameters:
    comment: |-
      Host to connect to. Format:
      tcp://<hostname>:<portnumber>
    label: remote-host
    short_id: r
    type: str
    value: tcp://sigint:50001
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample-Rate
    short_id: s
    type: eng_float
    value: 2.5e6
  states: {}
- name: tabje
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: Waterfall
    num_tabs: '2'
  states: {}
- name: vector_sorter
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Vector Sort And Threshold 
          
          This block does 2 things:
          - Sort a vector with numpy. Output this vector on port 0
          
          - Calculate the median (50%) and add the threshold. Output a vector on port 1.
          
          """

          def __init__(self, fftsize=4096, threshold=8.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              self.threshold = threshold
              self.fftsize = fftsize
              gr.sync_block.__init__(
                  self,
                  name='Vector Sort And Threshold',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=[(np.float32,fftsize),(np.float32,fftsize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              #self.example_param = example_param

          def work(self, input_items, output_items):
              # Sort the list
              sortlist = np.sort(input_items[0])
              # Output the sorted list on output 0
              output_items[0][:] = sortlist
              # Determine the median
              vecmedian = np.median(sortlist[:(int(self.fftsize/2))])
              # Output the calculated threshold as vector on output 1
              output_items[1][:] =  [self.threshold + vecmedian]*self.fftsize
              return len(output_items[0])
    fftsize: fftsize
    threshold: threshold
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: remote
    timeout: '100'
    type: float
    vlen: fftsize
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_add_const_vxx_0, '0', vector_sorter, '0']
- [blocks_vector_source_x_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_vector_to_stream_0, '0', qtgui_time_raster_sink_x_0, '0']
- [vector_sorter, '0', qtgui_vector_sink_f_0, '2']
- [vector_sorter, '1', qtgui_vector_sink_f_0, '1']
- [zeromq_sub_source_0, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
