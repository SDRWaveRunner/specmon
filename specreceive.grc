options:
  parameters:
    author: PE1RIK
    generate_options: qt_gui
    id: specreceive
    output_language: python
    title: Specmon_Receiver
  states: {}

blocks:
- name: fftsize
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 48e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '20'
    value: '8.0'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[threshold]*fftsize'
    vlen: fftsize
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    comment: |-
      X-start: freq-(samp_rate/2)
      X-step: samp_rate/fftsize
    grid: 'True'
    nconnections: '2'
    showports: 'True'
    vlen: fftsize
    x_start: freq-(samp_rate/2)
    x_step: samp_rate/fftsize
    ymax: '55'
    ymin: '-40'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://remotehost.lan:50001
    timeout: '100'
    type: float
    vlen: fftsize
  states: {}

connections:
- [blocks_vector_source_x_0, '0', qtgui_vector_sink_f_0, '1']
- [zeromq_sub_source_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
